Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2022-01-06T07:06:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 06 07:06:08 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{38F2E8E5-8927-480D-B5B3-6FD9DBAC0AEF}\ifc * Database version: 5507 * Database creation date: Thu Jan 06 07:06:07 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 06 07:06:07 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 06 07:06:07 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 29992961_USA_11410740_EBA7848_EDST-CLST, 11410740_USA_EBA7848_EDST-CLST:29992961_USA_11410740_EBA7848_EDST-CLST:202165
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 29992961_USA_11410740_EBA7848_EDST-CLST
